# Keil uVision project ADC.uvprojx, settings and files
target ADC (6230000::V6.23::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ADC +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4
  c include: ../../Core/Inc;../../Drivers/STM32G4xx_HAL_Driver/Inc;../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../Drivers/CMSIS/Include;E:/STMCUMX1/dba99/STM32CubeG4-master/STM32CubeG4-master/Drivers/CMSIS/DSP/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../../Core/Src/: main.c gpio.c adc.c dac.c dma.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/: arm_cortexM4lf_math.lib
    ../../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.1.0
